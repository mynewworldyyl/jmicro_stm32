# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  JM_STM32=1  JM_ENV=0 SLOG_ENABLE=1
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\jm_client;.\jmicro_stm32;.\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h Serial.c Serial.h CountSensor.h CountSensor.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group jmicro_stm32
    ./jmicro_stm32/: jm_cfg.c jm_cfg.h jm_fs.c jm_fs.h jm_net.h jm_serial.c jm_stm32.h jm_tcpconn.c jm_udpconn.c stm32_adapter.h jm_stm32_runner.c jm_ctrl.c jm_ctrl.h
  group test
    ./test/: test_tcp.c test_rpc.c test_udp.c test_press_udp.c test.h test_press_rpc.c test_press_tcp.c test_ps.c
  group jm_client
    ./jm_client/: c_types.h debug.h jm.h jm_buffer.c jm_buffer.h jm_cfg_def.h jm_cli_encode.h jm_cli_kv.h jm_cli_ps.h jm_cli_rpc.h jm_cli_timer.h jm_client.c jm_client.h jm_cmd.h jm_cons.h jm_constants.h jm_mem.c jm_mem.h jm_msg.c jm_msg.h jm_msg_elist.h jm_msg_emap.h jm_msg_extra.h jm_options.h jm_port.h jm_printf.h jm_runner.c jm_stdcimpl.c jm_stdcimpl.h
